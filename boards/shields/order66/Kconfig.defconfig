## boards/shields/order66/Kconfig.shield
```kconfig
# Copyright (c) 2025 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_ORDER66
    def_bool $(shields_list_contains,order66)
```
